# Keil uVision project YZ_H7_Base.uvprojx, settings and files
target YZ_H7_Base (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: YZ_H7_Base +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_PWR_LDO_SUPPLY
  c misc: --locale=english --diag_suppress=1
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../BSP;../ASP;../APP;../BSP/24CXX;../BSP/IIC;../BSP/TOUCH;../LVGL_Port;../GUI/LVGL_GUI/generated;../GUI/LVGL_GUI/custom;../GUI/LVGL_GUI/generated/guider_customer_fonts;../Drivers/CMSIS/RTOS2/Include
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dac.c dma.c fdcan.c tim.c usart.c usb_otg.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_hcd.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group User/APP/Sys
    ../APP/: app_main.c app_sysparam.c app_alt_basic.c app_user_main.c app_target_test.c app_SendData.c
  group User/APP/Projeck
    ../APP/: app_GB10847.c app_GB10865.c app_GB1402S.c app_GB3001_GB3002.c app_ER17353.c app_ZC17353.c app_GB5745X.c app_TK100.c app_IR108175.c app_GB5753X.c app_GB7639_GB5753Z_GB5745Z.c app_GB11579.c
  group User/APP/UART
    ../APP/: app_uart1.c app_uart2.c app_uart3.c app_uart5.c app_uart7.c app_uart8.c app_XR_API.c
  group User/APP/PPS
    ../APP/: app_pps_ctrl.c
  group User/APP/CJson
    ../APP/: cJSON.c
  group User/APP/Debug
    ../APP/: debuger.c
  group User/BSP
    ../BSP/24CXX/: 24cxx.c
    ../BSP/IIC/: myiic.c
    ../BSP/TOUCH/: ctiic.c ft5206.c touch.c gt9xxx.c touch_test.c
    ../BSP/: bsp_file_operate.c bsp_lcd.c bsp_ENC.c bsp_key.c bsp_delay.c bsp_ADC.c bsp_interrupt_callback.c bsp_pwm.c bsp_motor.c bsp_DAC.c bsp_uart.c bsp_MB_slave.c bsp_SpeedCapture.c bsp_cpu_flash.c bsp_can.c bsp_pid.c
  group User/DOC
    ../DOC/: devlog.md readme.md
software components: CMSIS:CORE 6.2.0
